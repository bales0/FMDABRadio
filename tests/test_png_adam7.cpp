// Independent expected images are generated by run_sls_tests.py.
#include "../src/PngAdam7Scale.h"
#include "../src/DataCrc.h"
#include <cassert>
#include <cstdio>
#include <cstring>
#include <fstream>
#include <iterator>
#include <string>
#include <vector>
#include <chrono>

static std::vector<uint8_t> read(const std::string& path) {
  std::ifstream file(path.c_str(),std::ios::binary);
  assert(file.good());
  return std::vector<uint8_t>((std::istreambuf_iterator<char>(file)),{});
}
struct Sink {
  unsigned width=0,height=0,pumps=0;
  std::vector<uint16_t> pixels;
  std::vector<unsigned> seen;
};
static void pump(void* opaque) { if (opaque) ++static_cast<Sink*>(opaque)->pumps; }
static bool row(void* opaque,unsigned x,unsigned y,unsigned step,
                const uint16_t* pixels,unsigned count) {
  Sink& sink=*static_cast<Sink*>(opaque);
  assert(y<sink.height && count && step && count<=320);
  for (unsigned i=0;i<count;++i) {
    assert(x+i*step<sink.width);
    const size_t at=y*sink.width+x+i*step;
    assert(!sink.seen[at]++);
    sink.pixels[at]=pixels[i];
  }
  return true;
}
static bool cancel(void*,unsigned,unsigned,unsigned,const uint16_t*,unsigned) {
  return false;
}
int main(int argc,char** argv) {
  assert(radio_data::crc32(reinterpret_cast<const uint8_t*>("123456789"),9)==0xCBF43926U);
  constexpr size_t capacity=PngAdam7ArenaBytes-PngAdam7TileBytes;
  const size_t bytes=PngAdam7WorkspaceBytes();
  assert(bytes+7<=capacity);
  std::vector<uint64_t> arena(PngAdam7ArenaBytes/8+2,0xA5A5A5A5A5A5A5A5ULL);
  uint8_t* work=reinterpret_cast<uint8_t*>(arena.data()+1);
  unsigned valid=0,invalid=0;
  const auto start=std::chrono::steady_clock::now();
  for (int index=1;index<argc;++index) {
    const std::string name=argv[index];
    const auto data=read(name);
    PngAdam7Info info;
    if (name.find(".bad.")!=std::string::npos) {
      assert(!PngAdam7Decode(data.data(),data.size(),work,capacity,320,320,info));
      ++invalid;
    } else {
      const auto reference=read(name+".expected");
      Sink sink;
      assert(reference.size()>=8);
      memcpy(&sink.width,reference.data(),4);
      memcpy(&sink.height,reference.data()+4,4);
      const size_t pixels=size_t(sink.width)*sink.height;
      assert(reference.size()==8+2*pixels);
      std::vector<uint16_t> expected(pixels);
      memcpy(expected.data(),reference.data()+8,2*pixels);
      sink.pixels.resize(pixels);sink.seen.resize(pixels);
      assert(PngAdam7Decode(data.data(),data.size(),work,capacity,320,320,info,
                             row,&sink,pump));
      assert(sink.pixels==expected && sink.pumps);
      for (unsigned n:sink.seen) assert(n==1);
      assert(info.width==sink.width && info.height==sink.height);
      assert(!PngAdam7Decode(data.data(),data.size(),work,bytes-1,320,320,info));
      assert(!PngAdam7Decode(data.data(),data.size(),work,capacity,0,320,info));
      assert(!PngAdam7Decode(data.data(),data.size(),work,capacity,320,0,info));
      assert(!PngAdam7Decode(data.data(),data.size(),work,capacity,320,320,info,cancel));

      // Exercise the identical scale/stripe callback used on ST7735.
      PngAdam7Tile tile;
      assert(tile.fit(sink.width,sink.height,160,128));
      assert(tile.width<=160 && tile.height<=128);
      tile.pixels=reinterpret_cast<uint16_t*>(work+capacity);
      for (tile.top=0;tile.top<tile.height;tile.top+=tile.rows) {
        tile.rows=tile.height-tile.top;
        if (tile.rows>PngAdam7TileRows) tile.rows=PngAdam7TileRows;
        std::fill(tile.pixels,tile.pixels+PngAdam7TileBytes/2,0xDEADU);
        assert(PngAdam7Decode(data.data(),data.size(),work,capacity,320,320,
                               info,PngAdam7Tile::collect,&tile));
        for (unsigned y=0;y<tile.rows;++y) for (unsigned x=0;x<tile.width;++x) {
          const unsigned sx=x*sink.width/tile.width;
          const unsigned sy=(y+tile.top)*sink.height/tile.height;
          assert(tile.pixels[y*tile.width+x]==expected[sy*sink.width+sx]);
        }
      }
      if (valid==0 || (sink.width==320 && sink.height==320 && info.type==6)) {
        for (unsigned shift=1;shift<=7;++shift) {
          assert(PngAdam7Decode(data.data(),data.size(),work+shift,capacity-shift,
                                 320,320,info));
        }
        // Repeated use after reject/cancel must not leak decoder state.
        for (unsigned repeat=0;repeat<100;++repeat)
          assert(PngAdam7Decode(data.data(),data.size(),work,capacity,320,320,info));
        std::vector<uint8_t> guarded(bytes+8+16,0x96);
        for (unsigned shift=0;shift<8;++shift) {
          assert(PngAdam7Decode(data.data(),data.size(),guarded.data()+8+shift,
                                 bytes+8-shift,320,320,info));
          for (unsigned at=0;at<8+shift;++at) assert(guarded[at]==0x96);
          for (size_t at=8+bytes+8;at<guarded.size();++at) assert(guarded[at]==0x96);
          std::fill(guarded.begin(),guarded.end(),0x96);
        }
      }
      ++valid;
    }
    assert(arena.front()==0xA5A5A5A5A5A5A5A5ULL);
    assert(arena.back()==0xA5A5A5A5A5A5A5A5ULL);
  }
  PngAdam7Info nullInfo;
  assert(!PngAdam7Decode(nullptr,100,work,capacity,320,320,nullInfo));
  PngAdam7Tile invalidTile;
  assert(!invalidTile.fit(0,1,160,128));
  assert(!invalidTile.fit(321,1,160,128));
  assert(!invalidTile.fit(1,1,161,128));
  const auto ms=std::chrono::duration_cast<std::chrono::milliseconds>(
      std::chrono::steady_clock::now()-start).count();
  printf("Adam7 PASS: valid=%u hostile=%u state=%zu stripe=%zu arena=%zu elapsed=%lldms\n",
         valid,invalid,bytes,PngAdam7TileBytes,PngAdam7ArenaBytes,(long long)ms);
}
